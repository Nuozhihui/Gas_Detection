# Keil uVision project Detection.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Detection +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HA;.\HA\DHT11;.\HA\LCD;.\HA\ADC;.\HA\STEP
  group Source Group 1
    ./: STARTUP.A51 MAIN.c
  group Pio
    ./HA/LCD/: lcd.c
    ./HA/DHT11/: DHT11.c
    ./HA/ADC/: Gas.c
    ./HA/STEP/: STEP.c
