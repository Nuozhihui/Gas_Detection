# Keil uVision project Deteection.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Deteection +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Library\ADC;.\Library\DHT11;.\Library\LCD;.\Library\STEP;.\Library\Show;.\Library\KEY
  group Source Group 1
    ./: STARTUP.A51 MAIN.c
  group Pio
    ./Library/LCD/: lcd.c
    ./Library/STEP/: STEP.c
    ./Library/KEY/: KEY.c
  group Show
    ./Library/Show/: Show.c
